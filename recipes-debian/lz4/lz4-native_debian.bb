require lz4.inc
inherit native
