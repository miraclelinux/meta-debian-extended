FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://pr-18446-Update-expired-SCT-certificates.patch"
