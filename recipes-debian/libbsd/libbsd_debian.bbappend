FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-Set-Cflags-to-use-I-instead-of-isystem.patch \
"
