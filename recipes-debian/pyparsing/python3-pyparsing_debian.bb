# base recipe: meta/recipes-devtools/python/python3-pyparsing_2.4.7.bb
# base branch: master
# base commit: 79821d5a185e25384f5b6b5158b238bbee17c79e

inherit setuptools3
require python-pyparsing.inc
