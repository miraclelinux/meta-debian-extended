SRC_URI += "file://0007-Fix-control-path-where-we-have-str-as-uninitialized-.patch"
