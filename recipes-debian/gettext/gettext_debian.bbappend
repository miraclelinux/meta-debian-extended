PROVIDES_class-native = "virtual/gettext-native"
PACKAGECONFIG_class-native = ""
BBCLASSEXTEND_append = " native"
