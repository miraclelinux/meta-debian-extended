# base recipe: meta-openembedded/meta-python/recipes-devtools/python/python3-decorator_4.4.0.bb
# base branch: warrior
# base commit: a24acf94d48d635eca668ea34598c6e5c857e3f8

inherit setuptools3
require python-decorator.inc

