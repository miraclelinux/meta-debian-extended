# base recipe: meta-openembedded/meta-python/recipes-devtools/python/python3-slip-dbus_0.6.5.bb
# base branch: warrior
# base commit: a24acf94d48d635eca668ea34598c6e5c857e3f8

inherit setuptools3
require python-slip-dbus.inc

