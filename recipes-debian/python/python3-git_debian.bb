# From: poky/meta/recipes-devtools/python/python3-git_2.1.11.bb Rev:
# Rev: 5afc46a9a9e23597ec189c59be38547b0b2cf967
require python-git.inc
inherit setuptools3
