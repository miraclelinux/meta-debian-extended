# base recipe: meta/recipes-devtools/python/python3-smmap_2.0.5.bb
# base branch: warrior
# base commit: 1b15b02b119221791f564ea94987336fbf00ca2c

inherit setuptools3
require python-smmap.inc
