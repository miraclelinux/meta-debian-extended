# base recipe: meta-python/recipes-devtools/python/python3-html5lib_1.0.1.bb
# base branch: warrior
# base commit: 8551d233d1e94ae295d85677c9306d43aeb752ef

inherit setuptools3
require python-html5lib.inc
