# base recipe: meta/recipes-devtools/python/python3-subunit_1.3.0.bb
# base branch: warrior
# base commit: 2f214b2e17d34084ddd5b5261a991a29d891891c

inherit setuptools3
require python-subunit.inc
