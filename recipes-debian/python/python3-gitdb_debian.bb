# base recipe: meta/recipes-devtools/python/python3-gitdb_2.0.5.bb
# base branch: warrior
# base commit: 97e68f42bbfd8ec9bafab5c30f38cfb8f3dd5e3e

inherit setuptools3
require python-gitdb.inc
