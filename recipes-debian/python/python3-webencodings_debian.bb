# base recipe: meta-python/recipes-devtools/python/python3-webencodings_0.5.1.bb
# base branch: warrior
# base commit: 4fa2b14ee8067abc1f095cae49e32598e59e2e85

inherit setuptools3
require python-webencodings.inc
