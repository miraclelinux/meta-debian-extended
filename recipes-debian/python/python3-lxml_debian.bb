# base recipe: meta-python/recipes-devtools/python/python3-lxml_4.3.3.bb
# base branch: warrior
# base commit: 80cdc95a31dc08495d9de76b7bc9eb915a3dfaf9

inherit setuptools3
require python-lxml.inc
CLEANBROKEN = "1"
