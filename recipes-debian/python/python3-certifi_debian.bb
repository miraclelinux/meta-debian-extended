#base recipe: meta-openembedded/meta-python/recipes-devtools/python/python3-certifi_2019.3.9.bb
#base branch: warrior
#base commit: a24acf94d48d635eca668ea34598c6e5c857e3f8

inherit pypi setuptools3
require python-certifi.inc
