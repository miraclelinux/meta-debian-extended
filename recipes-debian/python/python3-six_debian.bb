# base recipe: meta/recipes-devtools/python/python3-six_1.12.0.bb
# base branch: warrior
# base commit: aadf0716edbad9002173800e15965eda33796ad5

inherit setuptools3
require python-six.inc
