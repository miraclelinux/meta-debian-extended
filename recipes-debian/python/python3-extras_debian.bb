# base recipe: meta/recipes-devtools/python/python3-extras_1.0.0.bb
# base branch: warrior
# base commit: 76fbee59374d282c9d7e62db95c0968745411777

inherit setuptools3
require python-extras.inc
