# base recipe: meta/recipes-devtools/python/python3-mako_1.0.7_bb
# base branch: warrior
# base commit: 23626bd9025aad8a10d7cb13796a493e9db816e1

inherit setuptools3
require python-mako.inc
